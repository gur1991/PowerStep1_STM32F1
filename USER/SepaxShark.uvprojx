# Keil uVision project SepaxShark.uvprojx, settings and files
target SepaxShark (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --c99
  c include: ..\CORE;..\USER;..\OBJ;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\USMART;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\Drivers\BSP\Components\Common;..\HARDWARE\Drivers\BSP\Components\powerSTEP01;..\HARDWARE\Drivers\BSP\STM32F1xx-Nucleo;..\HARDWARE\Drivers\BSP\X-NUCLEO-IHMxx;..\HARDWARE\UART3;..\STM32F10x_FWLib\inc;..\HARDWARE\LIGHT;..\HARDWARE\Cheminert;..\HARDWARE\PUMPS100;..\HARDWARE\PRINT;..\HARDWARE\BABY18;..\HARDWARE\TIMER;..\HARDWARE\AD_SPI;..\HARDWARE\Temperature;..\HARDWARE\Weight;..\HARDWARE\PowerStep01;..\HARDWARE\UART4;..\HARDWARE\DS18B20;..\HARDWARE\UART2;..\HARDWARE\UART_CHOOSE;..\HARDWARE\Config;..\HARDWARE\Electromagnetic;..\HARDWARE\RS232_protocol;..\HARDWARE\WDG;..\HARDWARE\Execute_Command;..\HARDWARE\TIME_INTERRUPT;..\HARDWARE\FM100;..\HARDWARE\S1125;..\HARDWARE\Liquid_Sensor
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_msp.c
  group CORE
    ../CORE/: core_cm3.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/Drivers/BSP/Components/powerSTEP01/: powerstep01.c
    ../HARDWARE/Drivers/BSP/STM32F1xx-Nucleo/: stm32f1xx_nucleo.c
    ../HARDWARE/Drivers/BSP/X-NUCLEO-IHMxx/: x_nucleo_ihm03a1_stm32f1xx.c x_nucleo_ihmxx.c
    ../HARDWARE/UART3/: uart3.c
    ../HARDWARE/LIGHT/: light.c
    ../HARDWARE/Cheminert/: Cheminert_c52.c
    ../HARDWARE/PUMPS100/: pump_s100.c
    ../HARDWARE/PRINT/: printpaper.c
    ../HARDWARE/BABY18/: baby18dad400.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/AD_SPI/: spi1.c
    ../HARDWARE/Temperature/: temperature.c
    ../HARDWARE/Weight/: weight.c
    ../HARDWARE/PowerStep01/: step01.c factory_many.c
    ../HARDWARE/UART4/: uart4.c
    ../HARDWARE/DS18B20/: ds18b20.c keep_temperature.c
    ../HARDWARE/UART2/: uart2.c
    ../HARDWARE/UART_CHOOSE/: uart_choose.c
    ../HARDWARE/Electromagnetic/: electromagnetic.c
    ../HARDWARE/RS232_protocol/: master_uart_control_interface.c slave_uart_control_interface.c uart_command_control_protocol.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/Execute_Command/: execute.c
    ../HARDWARE/TIME_INTERRUPT/: time_interrupt.c
    ../HARDWARE/FM100/: fm100.c
    ../HARDWARE/S1125/: S1125.c
    ../HARDWARE/Liquid_Sensor/: liquid_sensor.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
